File: IR-Controller/Hardware/IR-Controller.sch (KiCad schematic (older format))
At the start: 1 part, among them U1 PIC18LF2550

Commit message: Controller: Add battery holder
Parts:
- added BT1: Battery, Librray:BC-2003, symbol Library:Battery
Connections:
- net +3V0: now also BT1.1 (+)
- net GND: now also BT1.2 (-)
Changed lines of the file:
@@
 Wire Wire Line
 	4250 2050 4250 2150
+$Comp
+L Library:Battery BT1
+U 1 1 60036241
+P 1550 1600
+F 0 "BT1" H 1703 1596 50  0000 L CNN
+F 1 "Battery" H 1703 1505 50  0000 L CNN
+F 2 "Librray:BC-2003" H 1550 1600 50  0001 C CNN
+F 3 "${KIPRJMOD}/../../Datasheet/BC-2003.pdf" H 1550 1600 50  0001 C CNN
+F 4 "Battery Retainer Coin, 20.0mm 1 Cell SMD (SMT) Tab" H 1550 1600 50  0001 C CNN "Description"
+F 5 "MPD (Memory Protection Devices)" H 1550 1600 50  0001 C CNN "Manufacturer"
+F 6 "BC-2003" H 1550 1600 50  0001 C CNN "Manufacturer Part Number"
+F 7 "BC-2003-ND" H 1550 1600 50  0001 C CNN "Digi-Key Part Number"
+	1    1550 1600
+	1    0    0    -1
+$EndComp
+$Comp
+L power:+3V0 #PWR01
+U 1 1 600382A6
+P 1550 1450
+F 0 "#PWR01" H 1550 1300 50  0001 C CNN
+F 1 "+3V0" H 1565 1623 50  0000 C CNN
+F 2 "" H 1550 1450 50  0001 C CNN
+F 3 "" H 1550 1450 50  0001 C CNN
+	1    1550 1450
+	1    0    0    -1
+$EndComp
+$Comp
+L power:GND #PWR02
+U 1 1 60038C3B
+P 1550 1850
+F 0 "#PWR02" H 1550 1600 50  0001 C CNN
+F 1 "GND" H 1555 1677 50  0000 C CNN
+F 2 "" H 1550 1850 50  0001 C CNN
+F 3 "" H 1550 1850 50  0001 C CNN
+	1    1550 1850
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	1550 1450 1550 1500
+Wire Wire Line
+	1550 1800 1550 1850
 $EndSCHEMATC

Commit message: Controller: Add IR LED
Parts:
- added C1: 0.1uF, Librray:C_0402_1005Metric, symbol Library:C
- added D1: IN-S126ESGHIR, Librray:IN-S126ESGHIR, symbol Library:LED
- BT1: value Battery -> BC-2003
- U1: Description PIC PIC® 18F Microcontroller IC 8-Bit 48MHz 32KB (16K x 16)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 -> IC MCU 8BIT 32KB FLASH 28SOIC
Connections:
- net +3V0: now also C1.2
- net GND: now also C1.1
Changed lines of the file:
@@
 F 2 "Librray:SOIC-28_Width7.50mm_Pitch1.27mm" H 5700 4000 50  0001 C CNN
 F 3 "${KIPRJMOD}/../../Datasheet/PIC18F2455-2550-4455-4550 Data Sheet.pdf" H 6100 4300 50  0001 C CNN
-F 4 "PIC PIC® 18F Microcontroller IC 8-Bit 48MHz 32KB (16K x 16) FLASH 28-SOIC" H 4650 3350 50  0001 C CNN "Description"
+F 4 "IC MCU 8BIT 32KB FLASH 28SOIC" H 4650 3350 50  0001 C CNN "Description"
 F 5 "Microchip Technology" H 4650 3350 50  0001 C CNN "Manufacturer"
 F 6 "PIC18LF2550-I/SO" H 4650 3350 50  0001 C CNN "Manufacturer Part Number"
@@
 P 1550 1600
 F 0 "BT1" H 1703 1596 50  0000 L CNN
-F 1 "Battery" H 1703 1505 50  0000 L CNN
+F 1 "BC-2003" H 1703 1505 50  0000 L CNN
 F 2 "Librray:BC-2003" H 1550 1600 50  0001 C CNN
 F 3 "${KIPRJMOD}/../../Datasheet/BC-2003.pdf" H 1550 1600 50  0001 C CNN
@@
 Wire Wire Line
 	1550 1800 1550 1850
+$Comp
+L Library:C C1
+U 1 1 5FE20484
+P 3550 1550
+F 0 "C1" V 3571 1415 50  0000 R CNN
+F 1 "0.1uF" V 3480 1415 50  0000 R CNN
+F 2 "Librray:C_0402_1005Metric" H 3400 1750 50  0001 C CNN
+F 3 "" H 3400 1750 50  0001 C CNN
+F 4 "CAP CER 0.1UF 25V X7R 0402" V 3550 1550 50  0001 C CNN "Description"
+F 5 "KEMET" V 3550 1550 50  0001 C CNN "Manufacturer"
+F 6 "C0402C104K3RAC7411" V 3550 1550 50  0001 C CNN "Manufacturer Part Number"
+F 7 "399-C0402C104K3RAC7411CT-ND" V 3550 1550 50  0001 C CNN "Digi-Key Part Number"
+	1    3550 1550
+	0    -1   -1   0
+$EndComp
+$Comp
+L power:+3V0 #PWR03
+U 1 1 60030181
+P 3550 1350
+F 0 "#PWR03" H 3550 1200 50  0001 C CNN
+F 1 "+3V0" H 3565 1523 50  0000 C CNN
+F 2 "" H 3550 1350 50  0001 C CNN
+F 3 "" H 3550 1350 50  0001 C CNN
+	1    3550 1350
+	1    0    0    -1
+$EndComp
+$Comp
+L power:GND #PWR04
+U 1 1 60030711
+P 3550 1750
+F 0 "#PWR04" H 3550 1500 50  0001 C CNN
+F 1 "GND" H 3555 1577 50  0000 C CNN
+F 2 "" H 3550 1750 50  0001 C CNN
+F 3 "" H 3550 1750 50  0001 C CNN
+	1    3550 1750
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	3550 1400 3550 1350
+Wire Wire Line
+	3550 1750 3550 1700
+$Comp
+L Library:LED D1
+U 1 1 60035D25
+P 6500 2550
+F 0 "D1" V 6449 2627 50  0000 L CNN
+F 1 "IN-S126ESGHIR" V 6540 2627 50  0000 L CNN
+F 2 "Librray:IN-S126ESGHIR" H 6510 2700 50  0001 C CNN
+F 3 "${KIPRJMOD}/../../Datasheet/IN-S126ESGHIR.pdf" H 6510 2700 50  0001 C CNN
+F 4 "SIDE VIEW / 1210 / 3.0X2.55X1.6" V 6500 2550 50  0001 C CNN "Description"
+F 5 "Inolux" V 6500 2550 50  0001 C CNN "Manufacturer"
+F 6 "IN-S126ESGHIR" V 6500 2550 50  0001 C CNN "Manufacturer Part Number"
+F 7 "1830-IN-S126ESGHIRCT-ND" V 6500 2550 50  0001 C CNN "Digi-Key Part Number"
+	1    6500 2550
+	0    1    1    0
+$EndComp
 $EndSCHEMATC

Commit message: Controller: Add IR LED driver transistor
Parts:
- added Q1: MMBT3904, Librray:SOT-23, symbol Library:NPN_BEC
- added R1: 15, Librray:R_0402_1005Metric, symbol Library:R
- added R2: 2.7k, Librray:R_0402_1005Metric, symbol Library:R
Connections:
- net +3V0: now also D1.2
- net GND: now also Q1.2
- net at U1.13 (RC2/CCP1): now also R2.2
- net at D1.1: now also R1.2
- new net: Q1.1, R2.1
- new net: Q1.3, R1.1
Other:
- moved on the sheet: D1
Changed lines of the file:
@@
 $EndComp
 $Comp
-L power:GND #PWR0101
+L power:GND #PWR06
 U 1 1 60030E14
 P 4200 4050
-F 0 "#PWR0101" H 4200 3800 50  0001 C CNN
+F 0 "#PWR06" H 4200 3800 50  0001 C CNN
 F 1 "GND" H 4205 3877 50  0000 C CNN
 F 2 "" H 4200 4050 50  0001 C CNN
@@
 	4200 4000 4200 3950
 $Comp
-L power:+3V0 #PWR0102
+L power:+3V0 #PWR07
 U 1 1 60031C1A
 P 4250 2050
-F 0 "#PWR0102" H 4250 1900 50  0001 C CNN
+F 0 "#PWR07" H 4250 1900 50  0001 C CNN
 F 1 "+3V0" H 4265 2223 50  0000 C CNN
 F 2 "" H 4250 2050 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:+3V0 #PWR03
+L power:+3V0 #PWR04
 U 1 1 60030181
 P 3550 1350
-F 0 "#PWR03" H 3550 1200 50  0001 C CNN
+F 0 "#PWR04" H 3550 1200 50  0001 C CNN
 F 1 "+3V0" H 3565 1523 50  0000 C CNN
 F 2 "" H 3550 1350 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:GND #PWR04
+L power:GND #PWR05
 U 1 1 60030711
 P 3550 1750
-F 0 "#PWR04" H 3550 1500 50  0001 C CNN
+F 0 "#PWR05" H 3550 1500 50  0001 C CNN
 F 1 "GND" H 3555 1577 50  0000 C CNN
 F 2 "" H 3550 1750 50  0001 C CNN
@@
 	3550 1750 3550 1700
 $Comp
+L Library:NPN_BEC Q1
+U 1 1 5FE4DCB4
+P 1650 3600
+F 0 "Q1" H 1600 3800 50  0000 R BNN
+F 1 "MMBT3904" H 1600 3700 50  0000 R BNN
+F 2 "Librray:SOT-23" H 1650 3600 50  0001 C CNN
+F 3 "${KIPRJMOD}/../../Datasheet/MMBT3904L SMMBT3904L General Purpose Transistor NPN Silicon.pdf" H 1650 3600 50  0001 C CNN
+F 4 "TRANS NPN 40V 200MA SOT23-3" H 1650 3600 50  0001 C CNN "Description"
+F 5 "ON Semiconductor" H 1650 3600 50  0001 C CNN "Manufacturer"
+F 6 "MMBT3904LT1G" H 1650 3600 50  0001 C CNN "Manufacturer Part Number"
+F 7 "MMBT3904LT1GOSCT-ND" H 1650 3600 50  0001 C CNN "Digi-Key Part Number"
+	1    1650 3600
+	-1   0    0    -1
+$EndComp
+$Comp
 L Library:LED D1
 U 1 1 60035D25
-P 6500 2550
-F 0 "D1" V 6449 2627 50  0000 L CNN
-F 1 "IN-S126ESGHIR" V 6540 2627 50  0000 L CNN
-F 2 "Librray:IN-S126ESGHIR" H 6510 2700 50  0001 C CNN
-F 3 "${KIPRJMOD}/../../Datasheet/IN-S126ESGHIR.pdf" H 6510 2700 50  0001 C CNN
-F 4 "SIDE VIEW / 1210 / 3.0X2.55X1.6" V 6500 2550 50  0001 C CNN "Description"
-F 5 "Inolux" V 6500 2550 50  0001 C CNN "Manufacturer"
-F 6 "IN-S126ESGHIR" V 6500 2550 50  0001 C CNN "Manufacturer Part Number"
-F 7 "1830-IN-S126ESGHIRCT-ND" V 6500 2550 50  0001 C CNN "Digi-Key Part Number"
-	1    6500 2550
-	0    1    1    0
-$EndComp
+P 1550 2850
+F 0 "D1" V 1550 2700 50  0000 R TNN
+F 1 "IN-S126ESGHIR" V 1450 2700 50  0000 R TNN
+F 2 "Librray:IN-S126ESGHIR" H 1560 3000 50  0001 C CNN
+F 3 "${KIPRJMOD}/../../Datasheet/IN-S126ESGHIR.pdf" H 1560 3000 50  0001 C CNN
+F 4 "SIDE VIEW / 1210 / 3.0X2.55X1.6" V 1550 2850 50  0001 C CNN "Description"
+F 5 "Inolux" V 1550 2850 50  0001 C CNN "Manufacturer"
+F 6 "IN-S126ESGHIR" V 1550 2850 50  0001 C CNN "Manufacturer Part Number"
+F 7 "1830-IN-S126ESGHIRCT-ND" V 1550 2850 50  0001 C CNN "Digi-Key Part Number"
+	1    1550 2850
+	0    -1   -1   0
+$EndComp
+$Comp
+L power:GND #PWR03
+U 1 1 60033686
+P 1550 3850
+F 0 "#PWR03" H 1550 3600 50  0001 C CNN
+F 1 "GND" H 1555 3677 50  0000 C CNN
+F 2 "" H 1550 3850 50  0001 C CNN
+F 3 "" H 1550 3850 50  0001 C CNN
+	1    1550 3850
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	1550 3800 1550 3850
+$Comp
+L Library:R R?
+U 1 1 5FE58D04
+P 1450 3200
+AR Path="/5FE20DA8/5FE58D04" Ref="R?"  Part="1"
+AR Path="/5FE379B8/5FE58D04" Ref="R?"  Part="1"
+AR Path="/5FE58D04" Ref="R1"  Part="1"
+F 0 "R1" H 1200 3150 50  0000 R TNN
+F 1 "15" H 1200 3250 50  0000 R TNN
+F 2 "Librray:R_0402_1005Metric" H 1450 3200 50  0001 C CNN
+F 3 "" H 1450 3200 50  0001 C CNN
+F 4 "CRGCQ 0402 15R 1%" H 1450 3200 50  0001 C CNN "Description"
+F 5 "TE Connectivity Passive Product" H 1450 3200 50  0001 C CNN "Manufacturer"
+F 6 "CRGCQ0402F15R" H 1450 3200 50  0001 C CNN "Manufacturer Part Number"
+F 7 "A129605CT-ND" H 1450 3200 50  0001 C CNN "Digi-Key Part Number"
+	1    1450 3200
+	-1   0    0    1
+$EndComp
+Wire Wire Line
+	1550 3350 1550 3400
+Wire Wire Line
+	1550 3000 1550 3050
+$Comp
+L power:+3V0 #PWR08
+U 1 1 60035A12
+P 1550 2650
+F 0 "#PWR08" H 1550 2500 50  0001 C CNN
+F 1 "+3V0" H 1565 2823 50  0000 C CNN
+F 2 "" H 1550 2650 50  0001 C CNN
+F 3 "" H 1550 2650 50  0001 C CNN
+	1    1550 2650
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	1550 2650 1550 2700
+$Comp
+L Library:R R?
+U 1 1 60036624
+P 2300 3500
+AR Path="/5FE20DA8/60036624" Ref="R?"  Part="1"
+AR Path="/5FE379B8/60036624" Ref="R?"  Part="1"
+AR Path="/60036624" Ref="R2"  Part="1"
+F 0 "R2" V 2050 3550 50  0000 R TNN
+F 1 "2.7k" V 1950 3550 50  0000 R TNN
+F 2 "Librray:R_0402_1005Metric" H 2300 3500 50  0001 C CNN
+F 3 "" H 2300 3500 50  0001 C CNN
+F 4 "CRGCQ 0402 2K7 1%" H 2300 3500 50  0001 C CNN "Description"
+F 5 "TE Connectivity Passive Product" H 2300 3500 50  0001 C CNN "Manufacturer"
+F 6 "CRGCQ0402F2K7" H 2300 3500 50  0001 C CNN "Manufacturer Part Number"
+F 7 "A129632CT-ND" H 2300 3500 50  0001 C CNN "Digi-Key Part Number"
+	1    2300 3500
+	0    -1   -1   0
+$EndComp
+Wire Wire Line
+	2850 3600 2450 3600
+Wire Wire Line
+	2150 3600 1850 3600
 $EndSCHEMATC
