# Repository sergeyvfx/IR-Volume-Control

File README.md:

# IR Volume Control

Volume control using DigiPot controlled by infrared remote control.

# IR Controllable Digipot

This part of the project is a what is actually controlling sound volume. It is
a digipot which is controlled by an infrared remote controller (similar to the
ones used by TVs).

The design and firmware files are in the `IR-Digipot` folder.

# IR Controller

This is a minimalistic implementation of infrared remote controller. It talks
to the `IR-Digipot`. Can be easily extended with more buttons to consolidate
all the remote controllers in the house!

## Licensing

All the work done and implemented for this project is licensed under the
terms of MIT license.

## KiCad design IR-Controller/hardware/IR-Controller.kicad_pcb

Parts:
BT1: BC-2003; Manufacturer Part Number BC-2003; Digi-Key Part Number BC-2003-ND
C1: 0.1uF; C_0402_1005Metric; Manufacturer Part Number C0402C104K3RAC7411; Digi-Key Part Number 399-C0402C104K3RAC7411CT-ND
D1: IN-S126ESGHIR; Manufacturer Part Number IN-S126ESGHIR; Digi-Key Part Number 1830-IN-S126ESGHIRCT-ND
J1: Conn_1x06_Generic; Conn_1x06_Socket_Pitch2.54mm_sideways
Q1: MMBT3904LT1G; SOT-23; Manufacturer Part Number MMBT3904LT1G; Digi-Key Part Number MMBT3904LT1GOSCT-ND
R1: 15; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F15R; Digi-Key Part Number A129605CT-ND
R2: 2.7k; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F2K7; Digi-Key Part Number A129632CT-ND
R3, R4: CRGCQ0402F10K; R_0402_1005Metric; Tolerance ±1%; Ratings AEC-Q200; Manufacturer Part Number CRGCQ0402F10K; Digi-Key Part Number A129639CT-ND
SW1, SW2: MCSLPT4644B1TR; Contact Rating @ Voltage 0.05A @ 12VDC; Manufacturer Part Number MCSLPT4644B1TR; Digi-Key Part Number 450-3379-1-ND
U1: PIC18LF2550-ISO; SOIC-28_Width7.50mm_Pitch1.27mm; Manufacturer Part Number PIC18F2550T-I/SO; Digi-Key Part Number PIC18F2550T-I/SOCT-ND

Connections:
+3V: BT1.1 (+), C1.2, D1.2, J1.5, U1.20 (VDD)
/MCLR: J1.6, R3.1, U1.1 (~MCLR~/VPP/RE3)
/PGC: J1.2, U1.27 (RB6/KBI2/PGC)
/PGD: J1.3, U1.28 (RB7/KBI3/PGD)
/SW_COL_0: R4.1, SW1.1, SW2.1, U1.21 (RB0/AN12/INT0/FLT0/SDI/SDA)
/SW_ROW_0: SW2.2, U1.25 (RB4/AN11/KBI0)
/SW_ROW_1: SW1.2, U1.26 (RB5/KBI1/PGM)
GND: BT1.2 (-), C1.1, J1.4, Q1.2, R3.2, R4.2, U1.8 (VSS), U1.15 (RC4/D-/VM), U1.16 (RC5/D+/VP), U1.19 (VSS)
unnamed: D1.1, R1.2
unnamed: Q1.1, R2.1
unnamed: Q1.3, R1.1
unnamed: R2.2, U1.13 (RC2/CCP1)

Board: 2 copper layers, 40.1 x 80.1 mm, 12 parts (0 on the bottom side), 12 nets.

## KiCad design IR-Digipot/hardware/IR Digipot.kicad_pcb

Parts:
C5, C6, C19, C20, C23, C24, C25: 0.1uF; C_0402_1005Metric; Manufacturer Part Number C0402C104K3RAC7411; Digi-Key Part Number 399-C0402C104K3RAC7411CT-ND
C7, C8: 10uF; CP_Elec_5x5.4; Manufacturer Part Number UUQ1E100MCL1GB; Digi-Key Part Number 493-3202-1-ND
C9, C10: 150; C_0402_1005Metric; Manufacturer Part Number 04025C151KAT2A; Digi-Key Part Number 478-1091-1-ND
C11, C12, C13, C14: 47; C_0402_1005Metric; Manufacturer Part Number C0402C470J3RACAUTO; Digi-Key Part Number 399-17558-1-ND
C15, C16: 0.22 uF; C_0402_1005Metric; Manufacturer Part Number 0402YC224KAT2A; Digi-Key Part Number 478-0402YC224KAT2ACT-ND
C17, C18: 470uF; CP_Elec_8x10; Manufacturer Part Number UUQ1A471MCL1GS; Digi-Key Part Number 493-16097-1-ND
C21, C22: 10uF; C_0805_2012Metric; Manufacturer Part Number EMK212BB7106KG-T; Digi-Key Part Number 587-6139-1-ND
D4, D5: 1N914; SOD-523; Manufacturer Part Number 1N914BWT; Digi-Key Part Number 1N914BWTCT-ND
FB1: BLM15PG100SN1D; L_0402_1005Metric; Manufacturer Part Number BLM15PG100SN1D; Digi-Key Part Number 490-5976-1-ND
J3, J4: STX-3500-5NTR; Manufacturer Part Number STX-3500-5NTR; Digi-Key Part Number 2092-STX-3500-5NCT-ND
Q1, Q3: MMBT3904LT1G; SOT-23; Manufacturer Part Number MMBT3904LT1G; Digi-Key Part Number MMBT3904LT1GOSCT-ND
Q2, Q4: MMBT3906LT1G; SOT-23; Manufacturer Part Number MMBT3906LT1G; Digi-Key Part Number MMBT3906LT1GOSCT-ND
R7, R8: 680; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F680R; Digi-Key Part Number A129625CT-ND
R9, R10, R19, R20: 22K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F22K; Digi-Key Part Number A129643CT-ND
R11, R12, R15, R16: 12K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F12K; Digi-Key Part Number A129640CT-ND
R13, R14: 47K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F47K; Digi-Key Part Number A129647CT-ND
R17, R18: 10K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F10K; Digi-Key Part Number A129639CT-ND
R21: 3.3K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F3K3; Digi-Key Part Number A129633CT-ND
R22: NC; R_0402_1005Metric
U4, U5: OPA2134UA_2K5; SOIC-8_Width3.9mm_Pitch1.27mm; Manufacturer Part Number OPA2134UA/2K5; Digi-Key Part Number 296-22024-1-ND
U6: AD5262BRUZ50-RL7; TSSOP-16_4.4x5mm_P0.65mm; Manufacturer Part Number AD5262BRUZ50-RL7; Digi-Key Part Number AD5262BRUZ50-RL7CT-ND

Connections:
+5VA: C5.2, C19.2, C21.2, C24.2, FB1.1, Q1.3, Q3.3, U4.8 (V+), U5.8 (V+), U6.5 (VDD); also elsewhere on the board
+5VD: R22.2; also elsewhere on the board
-5VA: C6.1, C20.1, C22.1, C25.1, Q2.3, Q4.3, R17.1, R18.1, U4.4 (V-), U5.4 (V-), U6.12 (VSS); also elsewhere on the board
/Audio/AUDIO_LEFT_ATT: R9.2, U6.3 (W1)
/Audio/AUDIO_LEFT_IN: C7.1, J3.2, R7.2
/Audio/AUDIO_LEFT_OUT: C17.2, J4.2
/Audio/AUDIO_LEFT_PREAMP: C13.2, R19.1, U5.1, U6.2 (A1)
/Audio/AUDIO_RIGHT_ATT: R10.2, U6.15 (W2)
/Audio/AUDIO_RIGHT_IN: C8.1, J3.3, R8.2
/Audio/AUDIO_RIGHT_OUT: C18.2, J4.3
/Audio/AUDIO_RIGHT_PREAMP: C14.2, R20.1, U5.7, U6.16 (A2)
/Audio/DIGIPOT_VL: FB1.2, R21.1, R22.1, U6.13 (VL)
DIGIPOT_SHDN: U6.6 (~SHDN~); also elsewhere on the board
GNDA: C5.1, C6.2, C9.2, C10.2, C19.1, C20.2, C21.1, C22.2, C23.1, C24.1, C25.2, J3.1, J4.1, R7.1, R8.1, R13.1, R14.1, U4.3 (+), U4.5 (+), U5.3 (+), U5.5 (+), U6.4 (B1), U6.11 (GND), U6.14 (B2); also elsewhere on the board
unnamed: C7.2, C9.1, R11.2
unnamed: C8.2, C10.1, R12.2
unnamed: C11.1, R9.1, R15.2, U4.2 (-)
unnamed: C11.2, C15.2, C17.1, Q1.2, Q2.2, R15.1
unnamed: C12.1, R10.1, R16.2, U4.6 (-)
unnamed: C12.2, C16.2, C18.1, Q3.2, Q4.2, R16.1
unnamed: C13.1, R11.1, R13.2, R19.2, U5.2 (-)
unnamed: C14.1, R12.1, R14.2, R20.2, U5.6 (-)
unnamed: C15.1, D4.2, Q1.1, U4.1
unnamed: C16.1, D5.2, Q3.1, U4.7
unnamed: C23.2, R21.2, U6.10 (~PR~)
unnamed: D4.1, Q2.1, R17.2
unnamed: D5.1, Q4.1, R18.2
SPI_CLK: U6.7 (CLK); also elsewhere on the board
SPI_CS_DIGIPOT: U6.9 (~CS~); also elsewhere on the board
SPI_MOSI: U6.8 (SDI); also elsewhere on the board

Notes on the sheet:
Input buffer and pre-amp
Digital potentiometer
Output buffer
Output jack
Input jack

Parts:
C1, C2: 4 pF; C_0402_1005Metric; Manufacturer Part Number CBR04C409B5GAC; Digi-Key Part Number 399-13246-1-ND
C3, C4: 0.1uF; C_0402_1005Metric; Manufacturer Part Number C0402C104K3RAC7411; Digi-Key Part Number 399-C0402C104K3RAC7411CT-ND
D1: SS14HE; SOD-323HE; Manufacturer Part Number SS14HE; Digi-Key Part Number SS14HECT-ND
D2, D3: HSMG-C170; HSMx-C170; Manufacturer Part Number HSMG-C170; Digi-Key Part Number 516-1434-1-ND
J1: Conn_1x06_Generic; Conn_1x06_D0.65mm_Pitch2.54mm_staggered
J2: Conn_1x03_Generic; Conn_1x03_D0.65mm_Pitch2.54mm_staggered
R1: 100K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F100K; Digi-Key Part Number A129651CT-ND
R2, R3, R4: 0; R_0402_1005Metric; Manufacturer Part Number CRG0402ZR; Digi-Key Part Number A106025CT-ND
R5, R6: 150; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F150R; Digi-Key Part Number A129617CT-ND
U1: TCM809LVNB713; SOT-23; Manufacturer Part Number TCM809LVNB713; Digi-Key Part Number TCM809LVNB713CT-ND
U2: PIC18F2550T-ISO; SOIC-28_Width7.50mm_Pitch1.27mm; Manufacturer Part Number PIC18LF2550-I/SO; Digi-Key Part Number PIC18LF2550-I/SO-ND
U3: TSOP75438TR; TSOP754; Manufacturer Part Number TSOP75438TR; Digi-Key Part Number TSOP75438CT-ND
X1: ABM8W-20.0000MHZ-4-K1Z-T3; Crystal_SMD_4Pin_3.2x2.5mm; Manufacturer Part Number ABM8W-20.0000MHZ-4-K1Z-T3; Digi-Key Part Number 535-14037-1-ND

Connections:
+5VA_SHTDN: U2.5 (RA3/AN3/VREF+); also elsewhere on the board
+5VD: C3.2, C4.2, J1.2, U1.3 (VDD), U2.20 (VDD), U3.2 (Vs); also elsewhere on the board
/CPU/IR_SERIAL: U2.25 (RB4/AN11/KBI0), U3.3 (Out)
/CPU/LED0: R5.1, U2.2 (RA0/AN0)
/CPU/LED1: R6.1, U2.3 (RA1/AN1)
/CPU/MCLR: D1.1, J1.1, U2.1 (~MCLR~/VPP/RE3)
DIGIPOT_SHDN: U2.6 (RA4/T0CKI/C1OUT/RCV); also elsewhere on the board
GNDD: C1.2, C2.1, C3.1, C4.1, D2.1, D3.1, J1.3, J2.3, R1.2, U1.1 (GND), U2.8 (VSS), U2.19 (VSS), U3.1 (GND), U3.4 (GND), X1.2, X1.4; also elsewhere on the board
unnamed: C1.1, U2.9 (OSC1/CLKI), X1.1
unnamed: C2.2, U2.10 (OSC2/CLKO/RA6), X1.3
unnamed: D1.2, R1.1, U1.2 (~RESET~)
unnamed: D2.2, R5.2
unnamed: D3.2, R6.2
unnamed: J1.4, U2.28 (RB7/KBI3/PGD)
unnamed: J1.5, U2.27 (RB6/KBI2/PGC)
unnamed: J2.1, U2.18 (RC7/RX/DT/SDO)
unnamed: J2.2, U2.17 (RC6/TX/CK)
unnamed: R2.1, U2.11 (RC0/T1OSO/T13CKI)
unnamed: R3.1, U2.12 (RC1/T1OSI/CCP2(1)/~UOE~)
unnamed: R4.1, U2.13 (RC2/CCP1)
SPI_CLK: R2.2; also elsewhere on the board
SPI_CS_DIGIPOT: R4.2; also elsewhere on the board
SPI_MOSI: R3.2; also elsewhere on the board

Notes on the sheet:
Capacitors are calculated for 4pF load capacitors and 2pF stray capacitance.
ICSP
UART

Parts:
C26: 4.7uF; C_1206_3216Metric; Manufacturer Part Number C1206C475K5RACTU; Digi-Key Part Number 399-11685-1-ND
C27, C28, C29, C30: 1uF; C_0603_1608Metric; Manufacturer Part Number UMK107AB7105KA-T; Digi-Key Part Number 587-3247-1-ND
C31: 0.1uF; C_0402_1005Metric; Manufacturer Part Number UMK105B7104KV-FR; Digi-Key Part Number 587-3498-1-ND
D6, D9: ESDA25P35; UDFN-2; Manufacturer Part Number ESDA25P35-1U1M; Digi-Key Part Number 497-16913-1-ND
D7: ESDA25W; SOT-323; Manufacturer Part Number ESDA25W; Digi-Key Part Number 497-6689-1-ND
D8: BAT54; SOD-523; Manufacturer Part Number BAT54KFILM; Digi-Key Part Number 497-5561-1-ND
J5: 1054500101; Manufacturer Part Number 1054500101; Digi-Key Part Number WM12856CT-ND
Q5, Q6: STL6P3LLH6; 8-PowerVDFN; Manufacturer Part Number STL6P3LLH6; Digi-Key Part Number 497-15315-1-ND
R23, R24, R30: NC; R_0402_1005Metric
R25, R28, R31, R32: 100K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F100K; Digi-Key Part Number A129651CT-ND
R26: 470; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F470R; Digi-Key Part Number A129623CT-ND
R27, R34: 1K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F1K0; Digi-Key Part Number A129627CT-ND
R29: 22K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F22K; Digi-Key Part Number A129643CT-ND
R33: 100; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F100R; Digi-Key Part Number A129615CT-ND
U7: STUSB4500QTR; QFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm; Manufacturer Part Number STUSB4500QTR; Digi-Key Part Number 497-18060-1-ND

Connections:
+2V7: C30.2, R23.1, R24.1, U7.23 (VREG_2V7)
GND: C26.1, C27.2, C28.1, C29.1, C30.1, D6.2, D7.3, D9.2, J5.A1 (GND), J5.A12 (GND), J5.B1 (GND), J5.B12 (GND), J5.SHLD (SHIELD), R25.1, R28.1, R32.1, U7.3 (VCONN), U7.10 (GND), U7.22 (VSYS), U7.25 (EP); also elsewhere on the board
unnamed: C27.1, D8.1, R26.1, R27.2
unnamed: C28.2, Q5.1, Q6.1, R30.2, R31.2, U7.24 (VDD)
unnamed: C29.2, U7.21 (VREG_1V2)
unnamed: C31.1, R33.1
unnamed: D7.1, J5.A5 (CC1), U7.1 (CC1DB), U7.2 (CC1)
unnamed: D7.2, J5.B5 (CC2), U7.4 (CC2), U7.5 (CC2DB)
unnamed: Q5.2, Q6.2, R29.2, R31.1, R33.2
unnamed: R23.2, R28.2, U7.13 (ADDR1)
unnamed: R24.2, R25.2, U7.12 (ADDR0)
unnamed: R27.1, U7.18 (VBUS_VS_DISCH)
unnamed: R29.1, U7.16 (VBUS_EN_SNK)
unnamed: R32.2, U7.6 (RESET)
unnamed: R34.1, U7.9 (DISCH)
VBUS: C26.2, D6.1, D8.2, J5.A4 (VBUS), J5.A9 (VBUS), J5.B4 (VBUS), J5.B9 (VBUS), Q5.3, R26.2, R30.1
VSNK: C31.2, D9.1, Q6.3, R34.2; also elsewhere on the board

Parts:
C32: 10uF; C_1210_3225Metric; Manufacturer Part Number UMK325AB7106KM-P; Digi-Key Part Number 587-6031-1-ND
C33: 220nF; C_0603_1608Metric; Manufacturer Part Number UMK107B7224KA-TR; Digi-Key Part Number 587-5958-1-ND
C34, C38, C47, C49: 0.1uF; C_0402_1005Metric; Manufacturer Part Number UMK105B7104KV-FR; Digi-Key Part Number 587-3498-1-ND
C35: 1nF; C_0402_1005Metric; Manufacturer Part Number 04025C102KAT2A; Digi-Key Part Number 478-1101-1-ND
C36: 22nF; C_0402_1005Metric; Manufacturer Part Number EMK105B7223KV-F; Digi-Key Part Number 587-1224-1-ND
C37, C45: 10nF; C_0402_1005Metric; Manufacturer Part Number UMK105B7103KV-F; Digi-Key Part Number 587-2238-1-ND
C39: 2.2nF; C_0402_1005Metric; Manufacturer Part Number 04025C222KAT2A; Digi-Key Part Number 478-1105-1-ND
C40, C41: 10uF; C_0805_2012Metric; Manufacturer Part Number EMK212BB7106KG-T; Digi-Key Part Number 587-6139-1-ND
C42, C44: 4.7uF; C_0805_2012Metric; Manufacturer Part Number LMK212B7475KG-T; Digi-Key Part Number 587-1442-1-ND
C43: 0.47uF; C_0402_1005Metric; Manufacturer Part Number LMK105B7474KV-F; Digi-Key Part Number 587-5912-1-ND
C46: 2.2uF; C_0603_1608Metric; Manufacturer Part Number LMK107B7225KA-T; Digi-Key Part Number 587-2983-1-ND
C48: 4.7uF; C_0805_2012Metric; Manufacturer Part Number TMK212AB7475KG-T; Digi-Key Part Number 587-2990-1-ND
D10: SS14HE; SOD-323HE; Manufacturer Part Number SS14HE; Digi-Key Part Number SS14HECT-ND
D11: ESDA7P120; D_0603_1610Metric; Manufacturer Part Number ESDA7P120-1U1M; Digi-Key Part Number 497-17159-1-ND
FB2, FB3, FB4: BLM15PG100SN1D; L_0402_1005Metric; Manufacturer Part Number BLM15PG100SN1D; Digi-Key Part Number 490-5976-1-ND
L1, L3: ACP3225-102-2P-T000; ACP3225; Manufacturer Part Number ACP3225-102-2P-T000; Digi-Key Part Number 445-8637-1-ND
L2: LQH44PN220MP0L; L_1515_4040Metric; Manufacturer Part Number LQH44PN220MP0L; Digi-Key Part Number 490-5331-1-ND
Q7: STL6P3LLH6; 8-PowerVDFN; Manufacturer Part Number STL6P3LLH6; Digi-Key Part Number 497-15315-1-ND
R35: 100K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F100K; Digi-Key Part Number A129651CT-ND
R36: 22K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F22K; Digi-Key Part Number A129643CT-ND
R37, R45: NC; R_0402_1005Metric
R38, R40: 100; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F100R; Digi-Key Part Number A129615CT-ND
R39: 1K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F1K0; Digi-Key Part Number A129627CT-ND
R41: 5.1K; R_0402_1005Metric; Manufacturer Part Number CPF0402B5K1E1; Digi-Key Part Number A102921CT-ND
R42: 698; R_0402_1005Metric; Manufacturer Part Number RP73PF1E698RBTD; Digi-Key Part Number A127304CT-ND
R43: 187K; R_0402_1005Metric; Manufacturer Part Number RC0402FR-07187KL; Digi-Key Part Number 311-187KLRCT-ND
R44: 82K; R_0402_1005Metric; Manufacturer Part Number RC0402FR-0782KL; Digi-Key Part Number 311-82.0KLRCT-ND
U8: L7985TR; VFDFPN-10_EP_3x3mm_P0.5mm; Manufacturer Part Number L7985TR; Digi-Key Part Number 497-13223-1-ND
U9: LM27761DSGR; WSON-8-EP_P0.5mm; Manufacturer Part Number LM27761DSGR; Digi-Key Part Number 296-44379-1-ND

Connections:
+5VA: C38.1, C42.2, FB2.2, U9.1 (VIN), U9.6 (EN); also elsewhere on the board
+5VA_SHTDN: R36.1; also elsewhere on the board
+5VD: C47.1, C48.1, FB3.2, Q7.1, R35.2, R37.1; also elsewhere on the board
-5VA: C49.1, FB4.2; also elsewhere on the board
/Power/+5V_UNFILTERED: C39.1, C40.2, C41.2, D11.1, L2.2, L3.3, R41.2
GND: C32.1, C33.1, C40.1, C41.1, D10.2, D11.2, L3.1, R42.1, U8.8 (GND), U8.11 (EP); also elsewhere on the board
GNDA: C37.1, C38.2, C42.1, C44.1, C46.1, C49.2, L1.2, R44.1, R45.2, U9.2 (GND), U9.9 (PAD); also elsewhere on the board
GNDD: C45.1, C47.2, C48.2, L1.1, L3.2; also elsewhere on the board
unnamed: C34.1, R38.1
unnamed: C34.2, L1.3, Q7.3, R37.2
unnamed: C35.1, R39.2, R40.2, R41.1, R42.2, U8.6 (FB)
unnamed: C35.2, C36.2, U8.5 (COMP)
unnamed: C36.1, R39.1
unnamed: C37.2, FB2.1, L1.4
unnamed: C39.2, R40.1
unnamed: C43.1, U9.7 (C-)
unnamed: C43.2, U9.8 (C+)
unnamed: C44.2, U9.3 (CPOUT)
unnamed: C45.2, FB3.1, L3.4
unnamed: C46.2, FB4.1, R43.2, R45.1, U9.4 (VOUT)
unnamed: D10.1, L2.1, U8.1 (OUT1), U8.2 (OUT2)
unnamed: Q7.2, R35.1, R36.2, R38.2
unnamed: R43.1, R44.2, U9.5 (VFB)
VSNK: C32.2, C33.2, U8.4 (EN), U8.9 (VCC1), U8.10 (VCC2); also elsewhere on the board

Notes on the sheet:
DC-DC for +5v
Filter for +5v rail
Switch for +5v in analog circuits

Board: 2 copper layers, 54.9 x 58.4 mm, 134 parts (0 on the bottom side), 81 nets.

## KiCad design IR-Digipot/Hardware/IR Digipot.kicad_pcb

Schematic: Audio.sch

Parts:
C5, C6, C19, C20, C23, C24, C25: 0.1uF; C_0402_1005Metric; Manufacturer Part Number C0402C104K3RAC7411; Digi-Key Part Number 399-C0402C104K3RAC7411CT-ND
C7, C8: 10uF; CP_Elec_5x5.4; Manufacturer Part Number UUQ1E100MCL1GB; Digi-Key Part Number 493-3202-1-ND
C9, C10: 150; C_0402_1005Metric; Manufacturer Part Number 04025C151KAT2A; Digi-Key Part Number 478-1091-1-ND
C11, C12, C13, C14: 47; C_0402_1005Metric; Manufacturer Part Number C0402C470J3RACAUTO; Digi-Key Part Number 399-17558-1-ND
C15, C16: 0.22 uF; C_0402_1005Metric; Manufacturer Part Number 0402YC224KAT2A; Digi-Key Part Number 478-0402YC224KAT2ACT-ND
C17, C18: 470uF; CP_Elec_8x10; Manufacturer Part Number UUQ1A471MCL1GS; Digi-Key Part Number 493-16097-1-ND
C21, C22: 10uF; C_0805_2012Metric; Manufacturer Part Number EMK212BB7106KG-T; Digi-Key Part Number 587-6139-1-ND
D1, D2: 1N914; SOD-523; Manufacturer Part Number 1N914BWT; Digi-Key Part Number 1N914BWTCT-ND
FB1: Ferrite_Bead; L_0402_1005Metric; Manufacturer Part Number BLM15PG100SN1D; Digi-Key Part Number 490-5976-1-ND
J3, J4: STX-3500-5NTR; Manufacturer Part Number STX-3500-5NTR; Digi-Key Part Number 2092-STX-3500-5NCT-ND
Q1, Q3: MMBT3904; SOT-23; Manufacturer Part Number MMBT3904LT1G; Digi-Key Part Number MMBT3904LT1GOSCT-ND
Q2, Q4: MMBT3906; SOT-23; Manufacturer Part Number MMBT3906LT1G; Digi-Key Part Number MMBT3906LT1GOSCT-ND
R5, R6: 680; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F680R; Digi-Key Part Number A129625CT-ND
R7, R8, R17, R18: 22K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F22K; Digi-Key Part Number A129643CT-ND
R9, R10, R13, R14: 12K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F12K; Digi-Key Part Number A129640CT-ND
R11, R12: 47K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F47K; Digi-Key Part Number A129647CT-ND
R15, R16: 10K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F10K; Digi-Key Part Number A129639CT-ND
R19: 3.3K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F3K3; Digi-Key Part Number A129633CT-ND
R20: NC; R_0402_1005Metric
U4, U5: OPA2134; SOIC-8_Width3.9mm_Pitch1.27mm; Manufacturer Part Number OPA2134UA/2K5; Digi-Key Part Number 296-22024-1-ND
U6: AD5262; TSSOP-16_4.4x5mm_P0.65mm; Manufacturer Part Number AD5262BRUZ50-RL7; Digi-Key Part Number AD5262BRUZ50-RL7CT-ND

Connections:
+5VA: C5.2, C19.2, C21.2, C24.2, FB1.1, Q1.3, Q3.3, U4.8, U5.8, U6.5; also elsewhere on the board
+5VD: R20.2; also elsewhere on the board
-5VA: C6.1, C20.1, C22.1, C25.1, Q2.3, Q4.3, R15.1, R16.1, U4.4, U5.4, U6.12; also elsewhere on the board
/Audio/AUDIO_LEFT_ATT: R7.2, U6.3
/Audio/AUDIO_LEFT_IN: C7.1, J3.2, R5.2
/Audio/AUDIO_LEFT_OUT: C17.2, J4.2
/Audio/AUDIO_LEFT_PREAMP: C13.2, R17.1, U5.1, U6.2
/Audio/AUDIO_RIGHT_ATT: R8.2, U6.15
/Audio/AUDIO_RIGHT_IN: C8.1, J3.3, R6.2
/Audio/AUDIO_RIGHT_OUT: C18.2, J4.3
/Audio/AUDIO_RIGHT_PREAMP: C14.2, R18.1, U5.7, U6.16
/Audio/DIGIPOT_VL: FB1.2, R19.1, R20.1, U6.13
DIGIPOT_SHDN: U6.6; also elsewhere on the board
GNDA: C5.1, C6.2, C9.2, C10.2, C19.1, C20.2, C21.1, C22.2, C23.1, C24.1, C25.2, J3.1, J4.1, R5.1, R6.1, R11.1, R12.1, U4.3, U4.5, U5.3, U5.5, U6.4, U6.11, U6.14; also elsewhere on the board
unnamed: C7.2, C9.1, R9.2
unnamed: C8.2, C10.1, R10.2
unnamed: C11.1, R7.1, R13.2, U4.2
unnamed: C11.2, C15.2, C17.1, Q1.2, Q2.2, R13.1
unnamed: C12.1, R8.1, R14.2, U4.6
unnamed: C12.2, C16.2, C18.1, Q3.2, Q4.2, R14.1
unnamed: C13.1, R9.1, R11.2, R17.2, U5.2
unnamed: C14.1, R10.1, R12.2, R18.2, U5.6
unnamed: C15.1, D1.2, Q1.1, U4.1
unnamed: C16.1, D2.2, Q3.1, U4.7
unnamed: C23.2, R19.2, U6.10
unnamed: D1.1, Q2.1, R15.2
unnamed: D2.1, Q4.1, R16.2
SPI_CLK: U6.7; also elsewhere on the board
SPI_CS_DIGIPOT: U6.9; also elsewhere on the board
SPI_MOSI: U6.8; also elsewhere on the board

Notes on the sheet:
Input buffer and pre-amp
Digital potentiometer
Output buffer
Output jack
Input jack

Schematic: CPU.sch

Parts:
C1, C2: 4 pF; C_0402_1005Metric; Manufacturer Part Number CBR04C409B5GAC; Digi-Key Part Number 399-13246-1-ND
C3, C4: 0.1uF; C_0402_1005Metric; Manufacturer Part Number C0402C104K3RAC7411; Digi-Key Part Number 399-C0402C104K3RAC7411CT-ND
J1: Conn_1x06_Generic; Conn_1x06_D0.65mm_Pitch2.54mm_staggered
J2: Conn_1x03_Generic; Conn_1x03_D0.65mm_Pitch2.54mm_staggered
R1: 100K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F100K; Digi-Key Part Number A129651CT-ND
R2, R3, R4: 0; R_0402_1005Metric; Manufacturer Part Number CRG0402ZR; Digi-Key Part Number A106025CT-ND
U1: TCM809; SOT-23; Manufacturer Part Number TCM809LVNB713; Digi-Key Part Number TCM809LVNB713CT-ND
U2: PIC18F2550T-I/SO; SOIC-28_Width7.50mm_Pitch1.27mm; Manufacturer Part Number PIC18F2550T-I/SO; Digi-Key Part Number PIC18F2550T-I/SOCT-ND
U3: TSOP754; Manufacturer Part Number TSOP75438TR; Digi-Key Part Number TSOP75438CT-ND
X1: 20 MHz; Crystal_SMD_4Pin_3.2x2.5mm; Manufacturer Part Number ABM8W-20.0000MHZ-4-K1Z-T3; Digi-Key Part Number 535-14037-1-ND

Connections:
+5VA_SHTDN: U2.5 (RA3/AN3/VREF+); also elsewhere on the board
+5VD: C3.2, C4.2, J1.2, U1.3, U2.20 (VDD), U3.2; also elsewhere on the board
/CPU/IR_SERIAL: U2.25 (RB4/AN11/KBI0), U3.3
/CPU/MCLR: J1.1, R1.1, U1.2, U2.1 (~MCLR~/VPP/RE3)
DIGIPOT_SHDN: U2.6 (RA4/T0CKI/C1OUT/RCV); also elsewhere on the board
GNDD: C1.2, C2.1, C3.1, C4.1, J1.3, J2.3, R1.2, U1.1, U2.8 (VSS), U2.19 (VSS), U3.1, U3.4, X1.2, X1.4; also elsewhere on the board
unnamed: C1.1, U2.9 (OSC1/CLKI), X1.1
unnamed: C2.2, U2.10 (OSC2/CLKO/RA6), X1.3
unnamed: J1.4, U2.28 (RB7/KBI3/PGD)
unnamed: J1.5, U2.27 (RB6/KBI2/PGC)
unnamed: J2.1, U2.18 (RC7/RX/DT/SDO)
unnamed: J2.2, U2.17 (RC6/TX/CK)
unnamed: R2.1, U2.11 (RC0/T1OSO/T13CKI)
unnamed: R3.1, U2.12 (RC1/T1OSI/CCP2(1)/~UOE~)
unnamed: R4.1, U2.13 (RC2/CCP1)
SPI_CLK: R2.2; also elsewhere on the board
SPI_CS_DIGIPOT: R4.2; also elsewhere on the board
SPI_MOSI: R3.2; also elsewhere on the board

Notes on the sheet:
Capacitors are calculated for 4pF load capacitors and 2pF stray capacitance.
ICSP
UART
