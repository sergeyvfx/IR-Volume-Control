# Repository sergeyvfx/IR-Volume-Control (continued)

## KiCad design IR-Digipot/Hardware/IR Digipot.kicad_pcb (continued)

Schematic: Power Delivery.sch

Parts:
C26: 4.7uF; C_1206_3216Metric; Manufacturer Part Number C1206C475K5RACTU; Digi-Key Part Number 399-11685-1-ND
C27, C28, C29, C30: 1uF; C_0603_1608Metric; Manufacturer Part Number UMK107AB7105KA-T; Digi-Key Part Number 587-3247-1-ND
C31: 0.1uF; C_0402_1005Metric; Manufacturer Part Number UMK105B7104KV-FR; Digi-Key Part Number 587-3498-1-ND
D3, D6: ESDA25P35; UDFN-2; Manufacturer Part Number ESDA25P35-1U1M; Digi-Key Part Number 497-16913-1-ND
D4: ESDA25W; SOT-323; Manufacturer Part Number ESDA25W; Digi-Key Part Number 497-6689-1-ND
D5: BAT54; SOD-523; Manufacturer Part Number BAT54KFILM; Digi-Key Part Number 497-5561-1-ND
J5: Molex_1054500101; Manufacturer Part Number 1054500101; Digi-Key Part Number WM12856CT-ND
Q5, Q6: STL6P3LLH6; 8-PowerVDFN; Manufacturer Part Number STL6P3LLH6; Digi-Key Part Number 497-15315-1-ND
R21, R22, R28: NC; R_0402_1005Metric
R23, R26, R29, R30: 100K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F100K; Digi-Key Part Number A129651CT-ND
R24: 470; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F470R; Digi-Key Part Number A129623CT-ND
R25, R32: 1K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F1K0; Digi-Key Part Number A129627CT-ND
R27: 22K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F22K; Digi-Key Part Number A129643CT-ND
R31: 100; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F100R; Digi-Key Part Number A129615CT-ND
U7: STUSB4500QTR; QFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm; Manufacturer Part Number STUSB4500QTR; Digi-Key Part Number 497-18060-1-ND

Connections:
+2V7: C30.2, R21.1, R22.1, U7.23 (VREG_2V7)
GND: C26.1, C27.2, C28.1, C29.1, C30.1, D3.2, D4.3, D6.2, J5.A1, J5.A12, J5.B1, J5.B12, J5.SHLD, R23.1, R26.1, R30.1, U7.3 (VCONN), U7.10 (GND), U7.22 (VSYS), U7.25 (EP); also elsewhere on the board
unnamed: C27.1, D5.1, R24.1, R25.2
unnamed: C28.2, Q5.1, Q6.1, R28.2, R29.2, U7.24 (VDD)
unnamed: C29.2, U7.21 (VREG_1V2)
unnamed: C31.1, R31.1
unnamed: D4.1, J5.A5, U7.1 (CC1DB), U7.2 (CC1)
unnamed: D4.2, J5.B5, U7.4 (CC2), U7.5 (CC2DB)
unnamed: Q5.2, Q6.2, R27.2, R29.1, R31.2
unnamed: R21.2, R26.2, U7.13 (ADDR1)
unnamed: R22.2, R23.2, U7.12 (ADDR0)
unnamed: R25.1, U7.18 (VBUS_VS_DISCH)
unnamed: R27.1, U7.16 (VBUS_EN_SNC)
unnamed: R30.2, U7.6 (RESET)
unnamed: R32.1, U7.9 (DISCH)
VBUS: C26.2, D3.1, D5.2, J5.A4, J5.A9, J5.B4, J5.B9, Q5.3, R24.2, R28.1
VSNK: C31.2, D6.1, Q6.3, R32.2; also elsewhere on the board

Schematic: Power.sch

Parts:
C32: 10uF; C_1210_3225Metric; Manufacturer Part Number UMK325AB7106KM-P; Digi-Key Part Number 587-6031-1-ND
C33: 220nF; C_0603_1608Metric; Manufacturer Part Number UMK107B7224KA-TR; Digi-Key Part Number 587-5958-1-ND
C34, C38, C47, C49: 0.1uF; C_0402_1005Metric; Manufacturer Part Number UMK105B7104KV-FR; Digi-Key Part Number 587-3498-1-ND
C35: 1nF; C_0402_1005Metric; Manufacturer Part Number 04025C102KAT2A; Digi-Key Part Number 478-1101-1-ND
C36: 22nF; C_0402_1005Metric; Manufacturer Part Number EMK105B7223KV-F; Digi-Key Part Number 587-1224-1-ND
C37, C45: 10nF; C_0402_1005Metric; Manufacturer Part Number UMK105B7103KV-F; Digi-Key Part Number 587-2238-1-ND
C39: 2.2nF; C_0402_1005Metric; Manufacturer Part Number 04025C222KAT2A; Digi-Key Part Number 478-1105-1-ND
C40, C41: 10uF; C_0805_2012Metric; Manufacturer Part Number EMK212BB7106KG-T; Digi-Key Part Number 587-6139-1-ND
C42, C44: 4.7uF; C_0805_2012Metric; Manufacturer Part Number LMK212B7475KG-T; Digi-Key Part Number 587-1442-1-ND
C43: 0.47uF; C_0402_1005Metric; Manufacturer Part Number LMK105B7474KV-F; Digi-Key Part Number 587-5912-1-ND
C46: 2.2uF; C_0603_1608Metric; Manufacturer Part Number LMK107B7225KA-T; Digi-Key Part Number 587-2983-1-ND
C48: 4.7uF; C_0805_2012Metric; Manufacturer Part Number TMK212AB7475KG-T; Digi-Key Part Number 587-2990-1-ND
D7: STPS3L60U; SOD-323HE; Manufacturer Part Number SS14HE; Digi-Key Part Number SS14HECT-ND
D8: ESDA7P120; D_0603_1610Metric; Manufacturer Part Number ESDA7P120-1U1M; Digi-Key Part Number 497-17159-1-ND
FB2, FB3, FB4: Ferrite_Bead; L_0402_1005Metric; Manufacturer Part Number BLM15PG100SN1D; Digi-Key Part Number 490-5976-1-ND
L1, L3: ACP3225; Manufacturer Part Number ACP3225-102-2P-T000; Digi-Key Part Number 445-8637-1-ND
L2: 22uH; L_1515_4040Metric; Manufacturer Part Number LQH44PN220MP0L; Digi-Key Part Number 490-5331-1-ND
Q7: STL6P3LLH6; 8-PowerVDFN; Manufacturer Part Number STL6P3LLH6; Digi-Key Part Number 497-15315-1-ND
R33: 100K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F100K; Digi-Key Part Number A129651CT-ND
R34: 22K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F22K; Digi-Key Part Number A129643CT-ND
R35, R43: NC; R_0402_1005Metric
R36, R38: 100; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F100R; Digi-Key Part Number A129615CT-ND
R37: 1K; R_0402_1005Metric; Manufacturer Part Number CRGCQ0402F1K0; Digi-Key Part Number A129627CT-ND
R39: 5.1K; R_0402_1005Metric; Manufacturer Part Number CPF0402B5K1E1; Digi-Key Part Number A102921CT-ND
R40: 698; R_0402_1005Metric; Manufacturer Part Number RP73PF1E698RBTD; Digi-Key Part Number A127304CT-ND
R41: 187K; R_0402_1005Metric; Manufacturer Part Number RC0402FR-07187KL; Digi-Key Part Number 311-187KLRCT-ND
R42: 82K; R_0402_1005Metric; Manufacturer Part Number RC0402FR-0782KL; Digi-Key Part Number 311-82.0KLRCT-ND
U8: L7985TR; VFDFPN-10_EP_3x3mm_P0.5mm; Manufacturer Part Number L7985TR; Digi-Key Part Number 497-13223-1-ND
U9: LM27761; WSON-8-EP_P0.5mm; Manufacturer Part Number LM27761DSGR; Digi-Key Part Number 296-44379-1-ND

Connections:
+5VA: C38.1, C42.2, FB2.2, U9.1, U9.6; also elsewhere on the board
+5VA_SHTDN: R34.1; also elsewhere on the board
+5VD: C47.1, C48.1, FB3.2, Q7.1, R33.2, R35.1; also elsewhere on the board
-5VA: C49.1, FB4.2; also elsewhere on the board
/Power/+5V_UNFILTERED: C39.1, C40.2, C41.2, D8.1, L2.2, L3.3, R39.2
GND: C32.1, C33.1, C40.1, C41.1, D7.2, D8.2, L3.1, R40.1, U8.8, U8.11; also elsewhere on the board
GNDA: C37.1, C38.2, C42.1, C44.1, C46.1, C49.2, L1.2, R42.1, R43.2, U9.2, U9.9; also elsewhere on the board
GNDD: C45.1, C47.2, C48.2, L1.1, L3.2; also elsewhere on the board
unnamed: C34.1, R36.1
unnamed: C34.2, L1.3, Q7.3, R35.2
unnamed: C35.1, R37.2, R38.2, R39.1, R40.2, U8.6
unnamed: C35.2, C36.2, U8.5
unnamed: C36.1, R37.1
unnamed: C37.2, FB2.1, L1.4
unnamed: C39.2, R38.1
unnamed: C43.1, U9.7
unnamed: C43.2, U9.8
unnamed: C44.2, U9.3
unnamed: C45.2, FB3.1, L3.4
unnamed: C46.2, FB4.1, R41.2, R43.1, U9.4
unnamed: D7.1, L2.1, U8.1, U8.2
unnamed: Q7.2, R33.1, R34.2, R36.2
unnamed: R41.1, R42.2, U9.5
VSNK: C32.2, C33.2, U8.4, U8.9, U8.10; also elsewhere on the board

Notes on the sheet:
DC-DC for +5v
Filter for +5v rail
Switch for +5v in analog circuits

Board: 2 copper layers, 54.9 x 58.4 mm, 129 parts (0 on the bottom side), 76 nets.

## Code that names these connections

File IR-Controller/firmware/source/system/configuration.h:

// Copyright (c) 2020, Sergey Sharybin
//
// Permission is hereby granted, free of charge, to any person obtaining a copy
// of this software and associated documentation files (the "Software"), to
// deal in the Software without restriction, including without limitation the
// rights to use, copy, modify, merge, publish, distribute, sublicense, and/or
// sell copies of the Software, and to permit persons to whom the Software is
// furnished to do so, subject to the following conditions:
//
// The above copyright notice and this permission notice shall be included in
// all copies or substantial portions of the Software.
//
// THE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
// IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
// FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
// AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
// LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING
// FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS
// IN THE SOFTWARE.
//
// Author: Sergey Sharybin (sergey.vfx@gmail.com)

#ifndef SYSTEM_CONFIGURATION_H_
#define SYSTEM_CONFIGURATION_H_

////////////////////////////////////////////////////////////////////////////////
// Core.

// Software side configuration of the board.
//
// Includes settings like at which frequency core is running, which
// communication ports are enabled and so on.
//
// NOTE: Some settings are living together from chip configuration bits from
// the chip_configuration.h header. For example, if there are changes in PLL
// settings are made the core frequency is to be adjusted in this header.

// Frequency at which the Fosc is running.
#define FOSC_FREQ 8000000ul

// NOTE: The naming is a bit misleading. This define is used by macros like
// __delay_ms() to see how much to NOP. The calculation is to use the core
// frequency, not the frequency of the crystal oscillator.
#define _XTAL_FREQ FOSC_FREQ

////////////////////////////////////////////////////////////////////////////////
// Keypad configuration.

// Columns are responsible for listening in the sleep mode.
#define KEYPAD_COLUMN_0_TRIS TRISBbits.RB0
#define KEYPAD_COLUMN_0_PORT PORTBbits.RB0

#define KEYPAD_ROW_0_TRIS TRISBbits.RB4
#define KEYPAD_ROW_0_LAT LATBbits.LATB4

#define KEYPAD_ROW_1_TRIS TRISBbits.RB5
#define KEYPAD_ROW_1_LAT LATBbits.LATB5

////////////////////////////////////////////////////////////////////////////////
// Debug pin.

#define DEBUG_PIN_TRIS TRISAbits.RA0
#define DEBUG_PIN_LAT LATAbits.LATA0

#endif  // SYSTEM_CONFIGURATION_H_

## Commit log

2021-03-07 Add firmware
    Also organize into directories without spaces.
2021-03-07 Initial commit
    Pass on putting majority of hardware blocks together.
2021-03-07 Swap MOSI and CS uC pins
    Allows to route tracks more efficiently.
2021-03-07 Continue routing digipot receiver
    Minor touches to the USB-C PD tracks, routed signal paths of
    audio circuits.
    Added missing reset circuits for the digipot.
2021-03-07 Route microcontroller area
2021-03-07 Initial commit of IR-Controller firmware
    Currently only contains chip configuration and debug code to
    experiment with the sleep mode.
2021-03-07 Update exported documents
2021-03-07 Add schematic and board export
    Makes it easier to have an idea about what's going on in the project
    without having KiCAD installed.
2021-03-07 Prevision digipot power from +5VD
    The idea is to try to bring digipot running before powering on
    buffers with the goal of programming proper volume on power on.
    Should help reducing popping on power on.
2021-03-07 Finish routing IR digipot
    All nets are routed, no DRC errors reported.
    Next steps are to do little tweaks to topology to minimize track
    length, double-check the design and capabilities of the PCB house.
2021-03-07 Controller: Initial KiCAD project
2021-03-07 Make VSON pads be regular rectangular
    Some pads which are intended to be rectangular were set to be custom
    with rectangular anchor.
2021-03-07 Cleanup: Typo in function name
2021-03-07 Fully routed USB-C PD and +5VD regulators
    Zones will need some tweaks, but electrically those circuits
    are usable now.
2021-03-07 Rework power supply ground zones
    USB-C PD and +5VD regulator can now be considered final: small tweaks
    are possible, but overall seems all fine.
2021-03-07 Add revision and date to the board
2021-03-07 Commit schematic changes for digipot power
2021-03-07 Fix typo in STUSB4500 SNK pin name
2021-03-07 Remove connection from audio jacks switches
    Were wrongly connected to ground. The idea was to connect
    unused pads to big copper mass to give mechanical rigidity.
    Should be done using non-connected net.
2021-03-07 Wire high-side switch FET for +5VA
    The PIC port should be able to draw enough current to
    properly control the switch.
2021-03-07 Implement transmission of RC6 commands
    Currently hardcoded to transmit Volume Up for the receiver
    part every second.
2021-03-07 Return USB-C connector to proper side
    Some of the grounds are now disconnected, will be connected back as part
    of zones rework.
2021-03-07 Controller: Add battery holder
2021-03-07 Add status LEDs to the digipot
2021-03-07 Tweak star ground of digipot
2021-03-07 Fix wrong layer for IR LED courtyard
2021-03-07 Tweak silk screen of digipot
    Fix intersection of silk with other silk, and avoid
    overlap of silk on top of copper.
2021-03-07 Controller: Add IR LED
2021-03-07 Tweak digipot preamp gain
    Allows to feed professional equipment level of signal which is
    3.472 Vpp. There is enough swing to do 4 Vpp with the new gain.
2021-03-07 Controller: Add IR LED driver transistor
2021-03-07 Refactor library
    Split it into smaller files, which contains components related to each
    other.
    The goal is to make the library reusable across projects.
    The resistors and capacitors are still only generic symbols in the
    library and it is still up to designer to link to DigiKey. With time
    those components will become accessible via library as well.
2021-03-07 Make folder names be lowercase
    Matches other developer/code projects.
2021-03-07 Add missing MplabX project
2021-03-07 Ignore possible copy of datasheets
2021-03-07 Add missing project XML files
2021-03-07 Replace library folder with a submodule
2021-03-07 Use proper Schottky diode
    There was a discontinuity between component value and DigiKey part
    number. Use SS14 diode, which is more generic.
2021-03-07 Add diode between power monitor and MCLR
    Should protect the monitor from HV programming.
    Will also avoid possible scenario when the monitor will attempt
    ti pull MCLR low during programming.
2021-03-07 Add clang-format
2021-04-03 Initial version of controller suitable for debugging
2021-04-03 Version 1 of working firmware for Volume Up/Down
    Not ideal from the power consumption point of view: had to have 2 pins
    to be latched to 1. From quick measurements the sleep power consumption
    is 14uA. It is above datasheet and above some earlier tests. Maybe there
    is a trick to lower it down. As it stands currently, it is about 2 years
    in sleep mode. Not too bad, but not totally great either.
2021-04-03 Controller: Pull RC4 and RC5 to ground
    Those are digital inputs when USB is not used. Pull to ground to avoid
    excess power drain.
2021-04-03 Controller: Pull MCLR to ground via 10k resistor
    When MCLR is used the pin acts as an input. Pull to ground to avoid its
    floating state. Use 10k resistor so that the ICSP can still work.
    Also update the board.
2021-04-03 Controller: Allow sliding battery
    The power track was causing an intermediate short circuit when
    sliding battery in and out.
2021-04-04 Update exports
2021-04-04 Controller: Increase delay before repeats
    Makes it easier to ensure single step updates.
2021-04-04 Extend readme a bit and add photo of controller
2021-05-30 Digipot: Move labels to the copper layer
    Should make it look better with the manufacturing process.
2021-06-13 Use relative paths for libraries
2021-07-24 Updates for the first version of PCB
    - Remap IO pins to the schematic
    - Make volume to have 32 steps instead of 16
