File: IR-Digipot/Hardware/CPU.sch (KiCad schematic (older format))
At the start: 14 parts, among them J1 Conn_1x06_Generic, J2 Conn_1x03_Generic, U1 PIC18F2550T-I/SO, U2 TCM809, U3 TSOP754, X1 20 MHz

Commit message: Tweak digipot preamp gain
Allows to feed professional equipment level of signal which is
3.472 Vpp. There is enough swing to do 4 Vpp with the new gain.
Parts:
- renumbered C2 to C1, C3 to C2, C1 to C3, U2 to U1, U1 to U2
Changed lines of the file:
@@
 $EndDescr
 $Comp
-L power:GNDD #PWR0101
+L power:GNDD #PWR010
 U 1 1 5FE1F2A3
 P 4700 4350
-F 0 "#PWR0101" H 4700 4100 50  0001 C CNN
+F 0 "#PWR010" H 4700 4100 50  0001 C CNN
 F 1 "GNDD" H 4704 4195 50  0000 C CNN
 F 2 "" H 4700 4350 50  0001 C CNN
@@
 Connection ~ 4700 4250
 $Comp
-L power:+5VD #PWR0102
+L power:+5VD #PWR09
 U 1 1 5FE204AA
 P 4650 2350
-F 0 "#PWR0102" H 4650 2200 50  0001 C CNN
+F 0 "#PWR09" H 4650 2200 50  0001 C CNN
 F 1 "+5VD" H 4665 2523 50  0000 C CNN
 F 2 "" H 4650 2350 50  0001 C CNN
@@
 	4600 4250 4700 4250
 $Comp
-L Library:PIC18F2550 U1
+L Library:PIC18F2550 U2
 U 1 1 5FE29C8E
 P 4650 3350
-F 0 "U1" H 5200 4350 50  0000 L BNN
+F 0 "U2" H 5200 4350 50  0000 L BNN
 F 1 "PIC18F2550T-I/SO" H 5200 4250 50  0000 L BNN
 F 2 "Librray:SOIC-28_Width7.50mm_Pitch1.27mm" H 6100 4300 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Library:C C1
+L Library:C C3
 U 1 1 5FE20484
 P 3550 1550
-F 0 "C1" V 3571 1415 50  0000 R CNN
+F 0 "C3" V 3571 1415 50  0000 R CNN
 F 1 "0.1uF" V 3480 1415 50  0000 R CNN
 F 2 "Librray:C_0402_1005Metric" H 3400 1750 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:+5VD #PWR01
+L power:+5VD #PWR07
 U 1 1 5FE283BF
 P 3550 1350
-F 0 "#PWR01" H 3550 1200 50  0001 C CNN
+F 0 "#PWR07" H 3550 1200 50  0001 C CNN
 F 1 "+5VD" H 3565 1523 50  0000 C CNN
 F 2 "" H 3550 1350 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:GNDD #PWR02
+L power:GNDD #PWR08
 U 1 1 5FE290E9
 P 3550 1750
-F 0 "#PWR02" H 3550 1500 50  0001 C CNN
+F 0 "#PWR08" H 3550 1500 50  0001 C CNN
 F 1 "GNDD" H 3554 1595 50  0000 C CNN
 F 2 "" H 3550 1750 50  0001 C CNN
@@
 	3550 1700 3550 1750
 $Comp
-L Library:TCM809 U2
+L Library:TCM809 U1
 U 1 1 5FE25880
 P 2200 1750
-F 0 "U2" H 2072 1746 50  0000 R CNN
+F 0 "U1" H 2072 1746 50  0000 R CNN
 F 1 "TCM809" H 2072 1655 50  0000 R CNN
 F 2 "Librray:SOT-23" H 2650 1950 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:+5VD #PWR0103
+L power:+5VD #PWR04
 U 1 1 5FE2B259
 P 2200 1400
-F 0 "#PWR0103" H 2200 1250 50  0001 C CNN
+F 0 "#PWR04" H 2200 1250 50  0001 C CNN
 F 1 "+5VD" H 2215 1573 50  0000 C CNN
 F 2 "" H 2200 1400 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:GNDD #PWR0104
+L power:GNDD #PWR05
 U 1 1 5FE2B9AA
 P 2200 2250
-F 0 "#PWR0104" H 2200 2000 50  0001 C CNN
+F 0 "#PWR05" H 2200 2000 50  0001 C CNN
 F 1 "GNDD" H 2204 2095 50  0000 C CNN
 F 2 "" H 2200 2250 50  0001 C CNN
@@
 	3050 2700 3250 2700
 $Comp
-L power:GNDD #PWR0105
+L power:GNDD #PWR06
 U 1 1 5FE43D04
 P 2750 2250
-F 0 "#PWR0105" H 2750 2000 50  0001 C CNN
+F 0 "#PWR06" H 2750 2000 50  0001 C CNN
 F 1 "GNDD" H 2754 2095 50  0000 C CNN
 F 2 "" H 2750 2250 50  0001 C CNN
@@
 	2200 3500 2200 3250
 $Comp
-L Library:C C3
+L Library:C C2
 U 1 1 5FE2C5B6
 P 2100 3800
-F 0 "C3" V 2121 3665 50  0000 R CNN
+F 0 "C2" V 2121 3665 50  0000 R CNN
 F 1 "4 pF" V 2030 3665 50  0000 R CNN
 F 2 "Librray:C_0402_1005Metric" H 1950 4000 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:GNDD #PWR05
+L power:GNDD #PWR03
 U 1 1 5FE2F103
 P 2100 4100
-F 0 "#PWR05" H 2100 3850 50  0001 C CNN
+F 0 "#PWR03" H 2100 3850 50  0001 C CNN
 F 1 "GNDD" H 2104 3945 50  0000 C CNN
 F 2 "" H 2100 4100 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:GNDD #PWR03
+L power:GNDD #PWR01
 U 1 1 5FE2F5E3
 P 1400 4100
-F 0 "#PWR03" H 1400 3850 50  0001 C CNN
+F 0 "#PWR01" H 1400 3850 50  0001 C CNN
 F 1 "GNDD" H 1404 3945 50  0000 C CNN
 F 2 "" H 1400 4100 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:GNDD #PWR04
+L power:GNDD #PWR02
 U 1 1 5FE2FF95
 P 1750 4100
-F 0 "#PWR04" H 1750 3850 50  0001 C CNN
+F 0 "#PWR02" H 1750 3850 50  0001 C CNN
 F 1 "GNDD" H 1754 3945 50  0000 C CNN
 F 2 "" H 1750 4100 50  0001 C CNN
@@
 	6800 2500 6700 2500
 $Comp
-L power:+5VD #PWR0106
+L power:+5VD #PWR011
 U 1 1 5FE36B16
 P 6700 2050
-F 0 "#PWR0106" H 6700 1900 50  0001 C CNN
+F 0 "#PWR011" H 6700 1900 50  0001 C CNN
 F 1 "+5VD" H 6715 2223 50  0000 C CNN
 F 2 "" H 6700 2050 50  0001 C CNN
@@
 	6700 2600 6700 3050
 $Comp
-L power:GNDD #PWR0107
+L power:GNDD #PWR012
 U 1 1 5FE3ACDF
 P 6700 3050
-F 0 "#PWR0107" H 6700 2800 50  0001 C CNN
+F 0 "#PWR012" H 6700 2800 50  0001 C CNN
 F 1 "GNDD" H 6704 2895 50  0000 C CNN
 F 2 "" H 6700 3050 50  0001 C CNN
@@
 	7850 5500 7850 5700
 $Comp
-L power:GNDD #PWR08
+L power:GNDD #PWR016
 U 1 1 5FE4B614
 P 7850 5700
-F 0 "#PWR08" H 7850 5450 50  0001 C CNN
+F 0 "#PWR016" H 7850 5450 50  0001 C CNN
 F 1 "GNDD" H 7854 5545 50  0000 C CNN
 F 2 "" H 7850 5700 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:+5VD #PWR07
+L power:+5VD #PWR014
 U 1 1 5FE4C094
 P 7500 4850
-F 0 "#PWR07" H 7500 4700 50  0001 C CNN
+F 0 "#PWR014" H 7500 4700 50  0001 C CNN
 F 1 "+5VD" H 7515 5023 50  0000 C CNN
 F 2 "" H 7500 4850 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:GNDD #PWR09
+L power:GNDD #PWR015
 U 1 1 5FE5B57D
 P 7500 5700
-F 0 "#PWR09" H 7500 5450 50  0001 C CNN
+F 0 "#PWR015" H 7500 5450 50  0001 C CNN
 F 1 "GNDD" H 7504 5545 50  0000 C CNN
 F 2 "" H 7500 5700 50  0001 C CNN
@@
 	2750 2150 2750 2250
 $Comp
-L Library:C C2
+L Library:C C1
 U 1 1 5FE2B3B5
 P 1400 3800
-F 0 "C2" V 1421 3665 50  0000 R CNN
+F 0 "C1" V 1421 3665 50  0000 R CNN
 F 1 "4 pF" V 1330 3665 50  0000 R CNN
 F 2 "Librray:C_0402_1005Metric" H 1250 4000 50  0001 C CNN
@@
 	6750 4000 6750 3900
 $Comp
-L power:GNDD #PWR06
+L power:GNDD #PWR013
 U 1 1 5FE5ACFD
 P 6750 4000
-F 0 "#PWR06" H 6750 3750 50  0001 C CNN
+F 0 "#PWR013" H 6750 3750 50  0001 C CNN
 F 1 "GNDD" H 6754 3845 50  0000 C CNN
 F 2 "" H 6750 4000 50  0001 C CNN

Commit message: Add status LEDs to the digipot
Parts:
- added D1, D2: HSMG-C170, Librray:HSMx-C170, symbol Library:LED
- added R5, R6: 150, Librray:R_0402_1005Metric, symbol Library:R
Connections:
- net GNDD: now also D1.1, D2.1
- net LED0: now reaches U2.2 (RA0/AN0)
- net LED0: now also R5.1
- net LED1: now reaches U2.3 (RA1/AN1)
- net LED1: now also R6.1
- new net: D1.2, R5.2
- new net: D2.2, R6.2
Changed lines of the file:
@@
 	6800 2500 6700 2500
 $Comp
-L power:+5VD #PWR011
+L power:+5VD #PWR013
 U 1 1 5FE36B16
 P 6700 2050
-F 0 "#PWR011" H 6700 1900 50  0001 C CNN
+F 0 "#PWR013" H 6700 1900 50  0001 C CNN
 F 1 "+5VD" H 6715 2223 50  0000 C CNN
 F 2 "" H 6700 2050 50  0001 C CNN
@@
 	6700 2600 6700 3050
 $Comp
-L power:GNDD #PWR012
+L power:GNDD #PWR014
 U 1 1 5FE3ACDF
 P 6700 3050
-F 0 "#PWR012" H 6700 2800 50  0001 C CNN
+F 0 "#PWR014" H 6700 2800 50  0001 C CNN
 F 1 "GNDD" H 6704 2895 50  0000 C CNN
 F 2 "" H 6700 3050 50  0001 C CNN
@@
 	7850 5500 7850 5700
 $Comp
-L power:GNDD #PWR016
+L power:GNDD #PWR018
 U 1 1 5FE4B614
 P 7850 5700
-F 0 "#PWR016" H 7850 5450 50  0001 C CNN
+F 0 "#PWR018" H 7850 5450 50  0001 C CNN
 F 1 "GNDD" H 7854 5545 50  0000 C CNN
 F 2 "" H 7850 5700 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:+5VD #PWR014
+L power:+5VD #PWR016
 U 1 1 5FE4C094
 P 7500 4850
-F 0 "#PWR014" H 7500 4700 50  0001 C CNN
+F 0 "#PWR016" H 7500 4700 50  0001 C CNN
 F 1 "+5VD" H 7515 5023 50  0000 C CNN
 F 2 "" H 7500 4850 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:GNDD #PWR015
+L power:GNDD #PWR017
 U 1 1 5FE5B57D
 P 7500 5700
-F 0 "#PWR015" H 7500 5450 50  0001 C CNN
+F 0 "#PWR017" H 7500 5450 50  0001 C CNN
 F 1 "GNDD" H 7504 5545 50  0000 C CNN
 F 2 "" H 7500 5700 50  0001 C CNN
@@
 	6750 4000 6750 3900
 $Comp
-L power:GNDD #PWR013
+L power:GNDD #PWR015
 U 1 1 5FE5ACFD
 P 6750 4000
-F 0 "#PWR013" H 6750 3750 50  0001 C CNN
+F 0 "#PWR015" H 6750 3750 50  0001 C CNN
 F 1 "GNDD" H 6754 3845 50  0000 C CNN
 F 2 "" H 6750 4000 50  0001 C CNN
@@
 Wire Wire Line
 	1550 3350 1550 3850
+Wire Wire Line
+	3250 2800 2950 2800
+Wire Wire Line
+	3250 2900 2950 2900
+Text Label 2950 2800 2    50   ~ 0
+LED0
+Text Label 2950 2900 2    50   ~ 0
+LED1
+Text Label 5650 4850 2    50   ~ 0
+LED0
+Text Label 5650 4950 2    50   ~ 0
+LED1
+Wire Wire Line
+	5650 4950 6350 4950
+Wire Wire Line
+	6350 4950 6350 5100
+Wire Wire Line
+	5650 4850 6000 4850
+Wire Wire Line
+	6000 4850 6000 5100
+$Comp
+L Library:LED D2
+U 1 1 6018F3C2
+P 6350 5600
+F 0 "D2" V 6450 5650 50  0000 L CNN
+F 1 "HSMG-C170" V 6300 5500 50  0001 R CNN
+F 2 "Librray:HSMx-C170" H 6360 5750 50  0001 C CNN
+F 3 "" H 6360 5750 50  0001 C CNN
+F 4 "LED GREEN DIFFUSED CHIP SMD" V 6350 5600 50  0001 C CNN "Description"
+F 5 "Broadcom Limited" V 6350 5600 50  0001 C CNN "Manufacturer"
+F 6 "HSMG-C170" V 6350 5600 50  0001 C CNN "Manufacturer Part Number"
+F 7 "516-1434-1-ND" V 6350 5600 50  0001 C CNN "Digi-Key Part Number"
+	1    6350 5600
+	0    -1   -1   0
+$EndComp
+$Comp
+L Library:R R5
+U 1 1 6019487D
+P 6100 5250
+F 0 "R5" H 6070 5296 50  0000 L CNN
+F 1 "150" H 6070 5205 50  0000 L CNN
+F 2 "Librray:R_0402_1005Metric" H 6100 5250 50  0001 C CNN
+F 3 "" H 6100 5250 50  0001 C CNN
+F 4 "CRGCQ 0402 150R 1%" H 6100 5250 50  0001 C CNN "Description"
+F 5 "TE Connectivity Passive Product" H 6100 5250 50  0001 C CNN "Manufacturer"
+F 6 "CRGCQ0402F150R" H 6100 5250 50  0001 C CNN "Manufacturer Part Number"
+F 7 "A129617CT-ND" H 6100 5250 50  0001 C CNN "Digi-Key Part Number"
+	1    6100 5250
+	1    0    0    -1
+$EndComp
+$Comp
+L Library:R R6
+U 1 1 6019624A
+P 6450 5250
+F 0 "R6" H 6420 5296 50  0000 L CNN
+F 1 "150" H 6420 5205 50  0000 L CNN
+F 2 "Librray:R_0402_1005Metric" H 6450 5250 50  0001 C CNN
+F 3 "" H 6450 5250 50  0001 C CNN
+F 4 "CRGCQ 0402 150R 1%" H 6450 5250 50  0001 C CNN "Description"
+F 5 "TE Connectivity Passive Product" H 6450 5250 50  0001 C CNN "Manufacturer"
+F 6 "CRGCQ0402F150R" H 6450 5250 50  0001 C CNN "Manufacturer Part Number"
+F 7 "A129617CT-ND" H 6450 5250 50  0001 C CNN "Digi-Key Part Number"
+	1    6450 5250
+	1    0    0    -1
+$EndComp
+$Comp
+L power:GNDD #PWR011
+U 1 1 6019674C
+P 6000 5800
+F 0 "#PWR011" H 6000 5550 50  0001 C CNN
+F 1 "GNDD" H 6004 5645 50  0000 C CNN
+F 2 "" H 6000 5800 50  0001 C CNN
+F 3 "" H 6000 5800 50  0001 C CNN
+	1    6000 5800
+	1    0    0    -1
+$EndComp
+$Comp
+L power:GNDD #PWR012
+U 1 1 60196DAF
+P 6350 5800
+F 0 "#PWR012" H 6350 5550 50  0001 C CNN
+F 1 "GNDD" H 6354 5645 50  0000 C CNN
+F 2 "" H 6350 5800 50  0001 C CNN
+F 3 "" H 6350 5800 50  0001 C CNN
+	1    6350 5800
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	6350 5750 6350 5800
+Wire Wire Line
+	6000 5750 6000 5800
+Wire Wire Line
+	6000 5400 6000 5450
+Wire Wire Line
+	6350 5400 6350 5450
+$Comp
+L Library:LED D1
+U 1 1 60180CAB
+P 6000 5600
+F 0 "D1" V 6100 5650 50  0000 L CNN
+F 1 "HSMG-C170" V 5950 5700 50  0001 L CNN
+F 2 "Librray:HSMx-C170" H 6010 5750 50  0001 C CNN
+F 3 "" H 6010 5750 50  0001 C CNN
+F 4 "LED GREEN DIFFUSED CHIP SMD" V 6000 5600 50  0001 C CNN "Description"
+F 5 "Broadcom Limited" V 6000 5600 50  0001 C CNN "Manufacturer"
+F 6 "HSMG-C170" V 6000 5600 50  0001 C CNN "Manufacturer Part Number"
+F 7 "516-1434-1-ND" V 6000 5600 50  0001 C CNN "Digi-Key Part Number"
+	1    6000 5600
+	0    -1   -1   0
+$EndComp
 $EndSCHEMATC
